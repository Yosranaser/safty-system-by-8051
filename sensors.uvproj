# Keil uVision project sensors.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: calculator +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 calculator.c keypad.c lcd.c adc0804.c
  group New Group
    ./: keypad.h lcd.h ADC0804.h
